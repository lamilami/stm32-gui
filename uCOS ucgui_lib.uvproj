# Keil uVision project uCOS ucgui_lib.uvproj, settings and files
target 7tftlcd (ARM-ADS)
  device: STM32F103VG STMicroelectronics
  cpu: IRAM(0x20000000-0x20017FFF) IROM(0x8000000-0x80FFFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: uCOSDemo +hex
  c flags: OneElfS=1
  c define: STM32F10X_XL,USE_STDPERIPH_DRIVER,ARM_MATH_CM3
  c include: .\Source\APP;.\Source\FWLib\cm3;.\Source\FWLib\inc;.\Source\BSP;.\Source\FWLib;.\Source\Startup;.\Source\uCOS-II\Source;.\Source\uCOS-II\uC-CPU;.\Source\uCOS-II\uC-LIB;.\Source\uCOS-II\Ports;.\Source\uCGUI\Config;.\Source\uCGUI\emWinDemo;.\Source\uCGUI\LCDDriver;.\Source\uCGUI\uCGUIDemo;.\Source\uCGUI\LCDDriver\Touch;.\Source\uCOS-II\Source;.\Source\uCGUI\Core;.\Source\uCGUI\WM;.\Source\uCGUI\Widget;.\Source\uCGUI\GUIDemo;.\Source\SDHC\driver;.\Source\SDHC\fatfs;.\Source\gui_app;.\Source\gui_app\pinyin;.\Source\uCGUI\TouchCalibration;.\Source\Mot;.\Source\Net;.\Source\STM32F10x_DSP_Lib\src\asm\arm;.\Source\STM32F10x_DSP_Lib\inc;..\..\..\STM32F4\STM32F4xx_DSP_StdPeriph_Lib_V1.0.1\Libraries\CMSIS\Lib\ARM;..\..\..\STM32F4\STM32F4xx_DSP_StdPeriph_Lib_V1.0.1\Libraries\CMSIS\Include;.\Source\Lib
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group Startup
    ./Source/FWLib/cm3/: system_stm32f10x.c
    ./Source/startup/arm/: startup_stm32f10x_xl.s
  group APP
    ./Source/APP/: app.c app_cfg.h includes.h os_cfg.h stm32f10x_it.c stm32f10x_conf.h
  group gui_app
    ./Source/gui_app/: home.c MainTask.c Custormer.c KeyBoard_Win.c gui_app.c TimeSet.c LimitSpeedH.c Draw.c XYZ.c xyz_acc_para.c num_dialog.c TParameter.c Parameter.c LimitSpeedT.h LimitSpeedT.c BalancePars.c Balance.c
    ./Source/gui_app/pinyin/: PY_DEF.c
  group BSP
    ./Source/BSP/: bsp.c rtc.c AD54XX.c AD54XX.h rdprint.c rdprint.h ft5x06_ts.c ft5x06_ts.h
    ./Source/APP/: chinese_pinyin_search.c flash_AT45DB161D.c GUI_FontHZ_SongTi_16.c
    ./Source/Mot/: mot.c mot.h
    ./Source/gui_app/: MMA8452Q.c
    ./Source/uCGUI/TouchCalibration/: TouchCalibration.c
  group SDHC
    ./Source/SDHC/fatfs/: diskio.c ff.c
    ./Source/SDHC/: sdhc_test.C
    ./Source/SDHC/fatfs/option/: cc936.c
    ./Source/SDHC/driver/: sd_spi_driver.c sd_spi_driver.h
  group FWLib
    ./Source/FWLib/src/: stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_rtc.c stm32f10x_flash.c stm32f10x_fsmc.c misc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_sdio.c stm32f10x_dma.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_pwr.c
  group uCOS-Ⅱ/Ports
    ./Source/uCOS-II/Ports/: os_cpu_c.c os_dbg.c os_cpu.h os_cpu_a.asm
  group uCOS-II/CPU
    ./Source/uCOS-II/uC-CPU/: cpu_a.asm cpu_def.h cpu.h
  group uCOS-Ⅱ/Source
    ./Source/uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group uCOS-II/GUI_X
    ./Source/uCGUI/: GUI_X_Touch.c GUI_X_uCOS.c
  group uCGUI/LCDDriver
    ./Source/uCGUI/LCDDriver/Touch/: Touch.c
    ./Source/uCGUI/LCDDriver/: SSD1963.c ssd1963_ucgui.c
  group uCGUI/Config
    ./Source/uCGUI/Config/: GUIConf.h GUITouchConf.h LCDConf.h
    ./ouput/: ucGui.lib
  group Net
    ./Source/Net/: enc28j60.c enc28j60.h ip_arp_udp_tcp.c ip_arp_udp_tcp.h net.h spi_enc28j60.c spi_enc28j60.h tftp_server.c tftp_server.h tftputils.c tftputils.h web_server.c web_server.h
  group DSPX
    ./Source/STM32F4xx_DSP_StdPeriph_Lib_V1.0.1/Libraries/CMSIS/Lib/ARM/: arm_cortexM3l_math.lib
target RAM (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: uCOSDemo +hex
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER,SDHC_TEST,VECT_TAB_SRAM
  c include: .\Source\APP;.\Source\FWLib\cm3;.\Source\FWLib\inc;.\Source\BSP;.\Source\FWLib;.\Source\Startup;.\Source\uCOS-II\Source;.\Source\uCOS-II\uC-CPU;.\Source\uCOS-II\uC-LIB;.\Source\uCOS-II\Ports;.\Source\uCGUI\Config;.\Source\uCGUI\emWinDemo;.\Source\uCGUI\LCDDriver;.\Source\uCGUI\uCGUIDemo;.\Source\uCGUI\LCDDriver\Touch;.\Source\uCOS-II\Source;.\Source\uCGUI\Core;.\Source\uCGUI\WM;.\Source\uCGUI\Widget;.\Source\uCGUI\GUIDemo;.\Source\SDHC\driver;.\Source\SDHC\fatfs
  memory RVCT4: ROM 0x20000000 size 0xa000
  memory RVCT9: RAM 0x2000a000 size 0x4000
